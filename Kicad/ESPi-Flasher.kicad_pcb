# Repository nagius/ESPi-Flasher

File README.md:

# ESPi-Flasher

ESPi-Flasher is a development board for ESP8266-01 as a Raspberry Pi HAT.

It enables you to easily flash an ESP8266-01 from the Raspberry using the onboard 3.3v serial port.
Additional headers for GPIO and power rails (5v and 3.3v) are provided on the side of the hat to plug a breadboard or other testing devices.

## Component list

All the needed gerber files are in the [Gerber](Gerber/) directory. Create a zip of these files and send it to your manufacturer to print the PCB.

|Ref|Component|
|---|---|
|P1| 5x2 female header to be soldered up side down|
|U2| 4x2 female header for ESP8266-01|
|C1| 47µF capacitor|
|C2| 100nF capacitor|
|R1, R4| 200 ohms resistors|
|R2, R3| 1.47k ohms resistors|
|SW1, SW2, SW3| SPDT switch (ref. OS102011MS2QN1)|
|SW4| Cherry MX switch or equivalent|

## Usage

Plug the hat on top of the Raspberry Pi. P1 must be plugged at the top of the Pi header, on pins 1 to 10. 
The mounting hole should match the one on the Raspberry board.

### Flash mode

Slide SW2 and SW3 to the *Serial* position and SW1 to *Flash*. Then press the Reset button.

You can now use the Arduino IDE to flash it on the serial port `/dev/ttyAMA0`.
If your Raspberry is headless, copy the firmware via SSH and flash it with Esptool:

```
esptool.py --port /dev/ttyAMA0 write_flash -fm qio 0x00000 MyFirmware.ino.generic.bin
```

### Run modes

Slide SW1 to the *Run* position and press Reset.

Only GPIO 0 and 2 will be available, Tx and Rx remains connected to the serial port for debugging. You can access this port from the Raspberry with :

```
minicom -D /dev/ttyAMA0

```

#### If you need 3 GPIOs

Slide SW1 to the *Run* position, SW3 to *GPIO* and press Reset.

This code will need to be added in your sketch :

```
Serial.begin(115200, SERIAL_8N1, SERIAL_TX_ONLY);
pinMode(3,FUNCTION_3);

```

GPIO 3 will be accessible as a standard GPIO but the Tx pin remain connected to the serial port for write-only logging. (Useful for debugging)

#### If you need 4 GPIOs

Slide SW1 to the *Run* position, SW2 and SW3 to *GPIO* and press Reset.

All calls to `Serial.*` must be removed or commented out in your code, and this snippet need to be added :

```
pinMode(1,FUNCTION_3);
pinMode(3,FUNCTION_3);
```

All 4 GPIO pins are available as standard GPIO. Serial interface is not available anymore.

##  License

Copyleft 2020 - Nicolas AGIUS

Creative Commons - Attribution-NonCommercial-ShareAlike 4.0 International (CC BY-NC-SA 4.0)

## KiCad design Kicad/ESPi-Flasher.kicad_pcb

Parts:
C1: 47µF
C2: 100nF
P1: Pi Header
P2: +5V
P3: +3.3V
P4: GPIO
R1, R4: 200
R2, R3: 1.47k
SW1: Flash - Run
SW2: Tx - GPIO
SW3: Rx - GPIO
SW4: Reset
U1: ESP8266-01

Connections:
+3.3V: C1.1, P1.1, P3.1, R2.1, R3.1
GND: C1.2, P1.6, P1.9, P2.2 (PM), P3.2 (PM), R1.1, R4.2, SW4.1
unnamed: P1.10, SW2.3 (C)
unnamed: P1.8, SW3.3 (C)
unnamed: P4.4, SW3.1 (A)
unnamed: P4.2, SW2.1 (A)
unnamed: P1.2, P1.4, P2.1
unnamed: C2.1, R3.2, SW4.2
unnamed: C2.2, R4.1
unnamed: P4.1, SW1.1 (A)
unnamed: R1.2, SW1.3 (C)

Board: 2 copper layers, 50.0 x 40.0 mm, 14 parts (0 on the bottom side), 11 nets.

## Commit log

2020-05-28 Fix mounting hole offset
2020-06-11 Updated documentation
2020-06-11 Added CC license
2020-06-11 Fixed typo
